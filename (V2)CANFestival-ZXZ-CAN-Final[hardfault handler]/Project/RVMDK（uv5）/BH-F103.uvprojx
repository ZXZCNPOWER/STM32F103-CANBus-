# Keil uVision project BH-F103.uvprojx, settings and files
target CAN (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\CanFestival\inc;..\..\CanFestival\inc\stm32;..\..\CanFestival\driver;..\..\HARDWARE\ADC;..\..\HARDWARE\BEEP;..\..\HARDWARE\CAN;..\..\HARDWARE\EXTI;..\..\HARDWARE\KEY;..\..\HARDWARE\LED;..\..\HARDWARE\OLED;..\..\HARDWARE\PWM;..\..\HARDWARE\RGB;..\..\HARDWARE\TIMER3;..\..\User\delay;..\..\User\sys;..\..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c system_stm32f10x.c
    ../../HARDWARE/ADC/: adc.c
    ../../HARDWARE/BEEP/: beep.c
    ../../HARDWARE/CAN/: can_hw.c
    ../../HARDWARE/EXTI/: exti.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/OLED/: oled.c
    ../../HARDWARE/PWM/: timpwm.c
    ../../HARDWARE/RGB/: ws2811_rgb.c
    ../../HARDWARE/TIMER3/: timer3.c
    ../../CanFestival/driver/: stm32_canfestival.c TestMaster.c
  group CanFestival
    ../../CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group system
    ../../User/delay/: delay.c
    ../../User/sys/: sys.c
    ../../User/usart/: usart.c
